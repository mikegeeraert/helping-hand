# IAR project mpgl1-efmw-01.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3U2C Atmel ATSAM3U2C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: MPGL1; MPG1; EIE1
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\bsp; ..\drivers; ..\application; ..\..\firmware_mpg_common; ..\..\firmware_mpg_common\application; ..\..\firmware_mpg_common\cmsis; ..\..\firmware_mpg_common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mpgl1-efmw-01.hex
  ILINK.IlinkOutputFile: mpgl1.out
  ILINK.IlinkIcfFile: ..\..\firmware_mpg_common\sam3u2-flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: mpgl1-efmw-01.out
  group _BSP/Includes
    ../../firmware_mpg_common/: AT91SAM3U4.h configuration.h sam3u2-flash.icf typedefs.h
    ../bsp/: mpgl1-ehdw-03.h
  group _BSP/Source
    ../../firmware_mpg_common/: board_cstartup_iar.c
    ../bsp/: mpgl1-ehdw-03.c
  group _CMSIS
    ../../firmware_mpg_common/cmsis/: core_cm3.c core_cm3.h
  group _Drivers/Include
    ../../firmware_mpg_common/drivers/: adc12.h ant.h ant_api.h antdefines.h antmessage.h buttons.h exceptions.h interrupts.h leds.h messaging.h sam3u_i2c.h sam3u_ssp.h sam3u_uart.h timer.h utilities.h
    ../drivers/: lcd_nhd-c0220biz.h sdcard.h
  group _Drivers/Source
    ../../firmware_mpg_common/drivers/: adc12.c ant.c ant_api.c buttons.c exceptions.c interrupts.c leds.c messaging.c sam3u_i2c.c sam3u_ssp.c sam3u_uart.c timer.c utilities.c
    ../drivers/: lcd_nhd-c0220biz.c sdcard.c
  group Application/Include
    ../../firmware_mpg_common/application/: debug.h music.h tilt_controller.h
    ../application/: main.h mpgl1_board_test.h
  group Application/Source
    ../../firmware_mpg_common/application/: debug.c tilt_controller.c
    ../application/: main.c mpgl1_board_test.c
